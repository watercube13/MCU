# IAR project Sit&Heat03.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x40
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: tiny40 ATtiny40
  ICCAVR.CCDefines: DEBUG
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgtiny40.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.LCHeapSize: 0
  General.SCCStackSize: 0x25
  General.SCRStackSize: 20
  ICCAVR.CCDefines: NDEBUG
  group (top)
    ./: main.c
